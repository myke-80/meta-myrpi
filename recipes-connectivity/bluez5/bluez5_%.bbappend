FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
SRC_URI +=  " file://brcm43438.service "